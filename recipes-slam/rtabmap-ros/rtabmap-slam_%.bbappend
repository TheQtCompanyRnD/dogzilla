require recipes-slam/rtabmap-ros/rtabmap-ros-aarch64-hostlibs.inc
